Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: VESTA Jardinière PM.IFC
Time: 2020-07-03T11:43:07
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: H M20 A2_HM 20 (4)
In: Default Storey
Material: Inox A2-70

# IfcBeam: VEST-MUL-001_D 100 Ep.5 (4)
In: Default Storey
Material: AS7G06

# IfcBuildingElementProxy: VEST-JAR-PM-001_Lg 602 (3)
In: Default Storey
Name
VEST-JAR-PM-001_Lg 602 | PSet_Mass_Property - Mass Measure: 98.1759; Area Measure: 11.7336; Volume Measure: 0.0624212
2 x VEST-JAR-PM-001_Lg 602
